# Keil uVision project 9.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 9 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Drivers
  group STARTUP
    ./: STARTUP.A51
  group APP
    ../App/: main.c
  group DRIVERS
    ../Drivers/: ds18b20.c ds1302.c key.c smg.c
  group DOC
    ../Doc/: ReadMe.txt
