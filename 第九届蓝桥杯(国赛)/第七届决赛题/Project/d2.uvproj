# Keil uVision project d2.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: d2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Drivers;..\App
  group STARTUP
    ./: STARTUP.A51
  group DRIVERS
    ../Drivers/: display.c ds1302.c iic.c key.c tim.c
  group APP
    ../App/: main.c tool.c
