# Keil uVision project 1.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103V8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 1
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\Libraries\FWlib\inc;..\Libraries\CMSIS;..\..\Libraries\STM32F10x_StdPeriph_Driver;..\User;..\User\setp;..\User\GeneralTim;..\User\usart;..\User\SysTick
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/FWlib/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group USER
    ../User/: main.c stm32f10x_it.c
    ../User/setp/: setp.c
    ../User/GeneralTim/: bsp_GeneralTim.c
    ../User/usart/: bsp_usart.c
    ../User/SysTick/: bsp_SysTick.c
